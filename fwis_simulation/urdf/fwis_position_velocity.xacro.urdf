Commit message: add: avoiding obstacle

File: fwis_simulation/urdf/fwis_position_velocity.xacro.urdf (robot description, URDF)
Before this commit: robot mobile_assembly, 15 links, 14 joints
Joints:
- joint lidar_joint: origin xyz=0 0 -0.0357 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
